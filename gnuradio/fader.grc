options:
  parameters:
    generate_options: qt_gui
    id: fader
    output_language: python
    title: Fader Example
  states: {}

blocks:
- name: adj_time
  id: variable
  parameters:
    value: '2e-5'
  states: {}
- name: brightness_a
  id: variable
  parameters:
    value: fade_state
  states: {}
- name: brightness_b
  id: variable
  parameters:
    value: 100 - fade_state
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: chan_freq - offset
  states: {}
- name: chan_a
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,0,1,1
    label: Channel (A)
    maximum: '15'
    minimum: '0'
    outputmsgname: chan
    showvalue: 'True'
    type: int
    value: '0'
  states: {}
- name: chan_b
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,2,1,1
    label: Channel (B)
    maximum: '15'
    minimum: '0'
    outputmsgname: chan
    showvalue: 'True'
    type: int
    value: '1'
  states: {}
- name: chan_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: chan_width
  id: variable
  parameters:
    value: 6e4
  states: {}
- name: fade_state
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,4
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
    widget: slider
  states: {}
- name: group_a
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,1,1,1
    label: Group (A)
    maximum: '15'
    minimum: '0'
    outputmsgname: group
    showvalue: 'True'
    type: int
    value: '1'
  states: {}
- name: group_b
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,3,1,1
    label: Group (B)
    maximum: '15'
    minimum: '0'
    outputmsgname: group
    showvalue: 'True'
    type: int
    value: '1'
  states: {}
- name: live_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: offset
  id: variable
  parameters:
    value: samp_rate / 4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: .4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: offset + (chan_width / 4)
    low_cutoff_freq: offset - (chan_width / 4)
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: chan_width / 8
    win: window.WIN_HAMMING
  states: {}
- name: bitfield_to_timings_0
  id: bitfield_to_timings
  parameters:
    bit_high_time: '13e-4'
    bit_low_time: '6e-4'
    bit_sep_time: '7e-4'
    hello_time: '11e-4'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("NOW")
    period: '100'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate * adj_time)
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: message_muxer_0
  id: message_muxer
  parameters:
    active_gain: live_gain
    cutoff_time: '4'
    inactive_gain: '0'
    repeat_count: '5'
    time_between_repeats: '1e-5'
  states: {}
- name: message_sanitizer_0
  id: message_sanitizer
  parameters:
    brightness: fade_state
    chan: chan_a
    color: '24'
    group: group_a
    maintain_state: 'True'
    send_on_update: 'True'
  states: {}
- name: message_sanitizer_1
  id: message_sanitizer
  parameters:
    brightness: 100 - fade_state
    chan: chan_b
    color: '24'
    group: group_b
    maintain_state: 'True'
    send_on_update: 'True'
  states: {}
- name: message_to_bitfield_0
  id: message_to_bitfield
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(8e4)
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: int(8e4)
    srate: samp_rate
    tr_level: '.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {}
- name: timings_to_ookfloat_0
  id: timings_to_ookfloat
  parameters:
    false_value: '0.0'
    idle_value: '0'
    sample_rate: samp_rate
    sep_time: '1e-3'
    sep_value: '0.0'
    true_value: '1.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [band_pass_filter_0, '0', uhd_usrp_sink_0, '0']
- [bitfield_to_timings_0, debug, blocks_message_debug_1, print]
- [bitfield_to_timings_0, out, timings_to_ookfloat_0, in]
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_message_strobe_0, strobe, message_muxer_0, trigger]
- [blocks_moving_average_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [message_muxer_0, debug, blocks_message_debug_1, print]
- [message_muxer_0, gain, blocks_message_debug_1, print]
- [message_muxer_0, gain, uhd_usrp_sink_0, command]
- [message_muxer_0, out, message_to_bitfield_0, in]
- [message_sanitizer_0, debug, blocks_message_debug_1, print]
- [message_sanitizer_0, out, blocks_message_debug_0, print]
- [message_sanitizer_0, out, message_muxer_0, in]
- [message_sanitizer_1, debug, blocks_message_debug_1, print]
- [message_sanitizer_1, out, blocks_message_debug_0, print]
- [message_sanitizer_1, out, message_muxer_0, in]
- [message_to_bitfield_0, debug, blocks_message_debug_1, print]
- [message_to_bitfield_0, out, bitfield_to_timings_0, in]
- [timings_to_ookfloat_0, '0', blocks_moving_average_xx_0, '0']
- [timings_to_ookfloat_0, '0', qtgui_time_sink_x_0, '0']
- [timings_to_ookfloat_0, debug, blocks_message_debug_1, print]

metadata:
  file_format: 1
