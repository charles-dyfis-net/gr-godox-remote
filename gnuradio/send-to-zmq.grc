options:
  parameters:
    generate_options: qt_gui
    id: godox_rc_a5
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_tail_time
  id: variable
  parameters:
    value: 1/200.0
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: display_samples
  id: variable
  parameters:
    value: int(samp_rate * display_window_time)
  states: {}
- name: display_window_time
  id: variable
  parameters:
    value: (1.0 / 12.5)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: trigger_high
  id: variable
  parameters:
    value: '.04'
  states: {}
- name: trigger_low
  id: variable
  parameters:
    value: '.02'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: high
    false_value: 'False'
    true_key: high
    true_value: 'True'
    type: float
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: sample.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: sample.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate * burst_tail_time)
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: trigger_high
    init: '0'
    low: trigger_low
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '.9'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e5
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e5
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: ook_timings_0
  id: ook_timings
  parameters:
    edge_tag: '"high"'
    packet_tag: '"burst"'
    sample_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: display_samples
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    ylabel: Magnitude
    ymax: '.5'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: display_samples
    srate: samp_rate
    tr_level: trigger_high
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ylabel: Generated Waveform
  states: {state: disabled}
- name: timings_to_bin_0
  id: timings_to_bin
  parameters:
    forward_partial: 'False'
    hello_max: '13e-4'
    hello_min: '10e-4'
    high_max: '14e-4'
    low_max: '9e-4'
    low_min: '4e-4'
    sep_max: '8e-4'
    sep_min: '6e-4'
    textual_output: 'True'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:15263
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_burst_tagger_0, '0', blocks_burst_tagger_1, '0']
- [blocks_burst_tagger_1, '0', ook_timings_0, '0']
- [blocks_burst_tagger_1, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_threshold_ff_0, '0', blocks_burst_tagger_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_complex_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_short_0, '0']
- [blocks_threshold_ff_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_short_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [ook_timings_0, debug, blocks_message_debug_0, print]
- [ook_timings_0, out, timings_to_bin_0, in]
- [timings_to_bin_0, debug, blocks_message_debug_0, print]
- [timings_to_bin_0, out, zeromq_push_msg_sink_0, in]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
