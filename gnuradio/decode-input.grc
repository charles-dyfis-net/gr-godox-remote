options:
  parameters:
    generate_options: qt_gui
    id: godox_rc_a5
    output_language: python
    title: Capture RC-A5II Messages
  states: {}

blocks:
- name: burst_tail_time
  id: variable
  parameters:
    value: 1/200.0
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: display_samples
  id: variable
  parameters:
    value: int(samp_rate * display_window_time)
  states: {}
- name: display_window_time
  id: variable
  parameters:
    value: (1.0 / 12.5)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: trigger_high
  id: variable
  parameters:
    value: '.04'
  states: {}
- name: trigger_low
  id: variable
  parameters:
    value: '.02'
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: high
    false_value: 'False'
    true_key: high
    true_value: 'True'
    type: float
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate * burst_tail_time)
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: trigger_high
    init: '0'
    low: trigger_low
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '.9'
  states: {}
- name: decode_binfmt_0
  id: bitfield_to_message
  parameters: {}
  states: {}
- name: ook_timings_0
  id: ookfloat_to_timings
  parameters:
    edge_tag: '"high"'
    packet_tag: '"burst"'
    sample_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: display_samples
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    ylabel: Input Magnitude
    ymax: '.5'
    ymin: '0'
  states: {}
- name: timings_to_bin_0
  id: timings_to_bitfield
  parameters:
    forward_partial: 'False'
    hello_max: '13e-4'
    hello_min: '10e-4'
    high_max: '14e-4'
    low_max: '9e-4'
    low_min: '4e-4'
    sep_max: '8e-4'
    sep_min: '6e-4'
    textual_output: 'False'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_burst_tagger_0, '0', blocks_burst_tagger_1, '0']
- [blocks_burst_tagger_1, '0', ook_timings_0, '0']
- [blocks_burst_tagger_1, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_1, '0']
- [blocks_threshold_ff_0, '0', blocks_burst_tagger_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_short_0, '0']
- [blocks_threshold_ff_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_short_1, '0']
- [decode_binfmt_0, debug, blocks_message_debug_0, print]
- [decode_binfmt_0, out, blocks_message_debug_0, print]
- [ook_timings_0, debug, blocks_message_debug_0, print]
- [ook_timings_0, out, timings_to_bin_0, in]
- [timings_to_bin_0, debug, blocks_message_debug_0, print]
- [timings_to_bin_0, out, decode_binfmt_0, in]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
