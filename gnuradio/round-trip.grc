options:
  parameters:
    generate_options: qt_gui
    id: godox_rc_a5
    output_language: python
    title: Capture RC-A5II Messages
  states: {}

blocks:
- name: burst_tail_time
  id: variable
  parameters:
    value: 1/200.0
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: display_samples
  id: variable
  parameters:
    value: int(samp_rate * display_window_time)
  states: {}
- name: display_window_time
  id: variable
  parameters:
    value: (1.0 / 12.5)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: trigger_high
  id: variable
  parameters:
    value: '.04'
  states: {}
- name: trigger_low
  id: variable
  parameters:
    value: '.02'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bitfield_to_timings_0
  id: bitfield_to_timings
  parameters:
    bit_high_time: '13e-4'
    bit_low_time: '6e-4'
    bit_sep_time: '7e-4'
    hello_time: '13e-4'
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: high
    false_value: 'False'
    true_key: high
    true_value: 'True'
    type: float
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate * burst_tail_time)
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: trigger_high
    init: '0'
    low: trigger_low
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '.9'
  states: {}
- name: decode_binfmt_0
  id: bitfield_to_message
  parameters: {}
  states: {}
- name: encode_binfmt_0
  id: message_to_bitfield
  parameters: {}
  states: {}
- name: message_sanitizer_0
  id: message_sanitizer
  parameters: {}
  states: {}
- name: ook_timings_0
  id: ookfloat_to_timings
  parameters:
    edge_tag: '"high"'
    packet_tag: '"burst"'
    sample_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: display_samples
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ylabel: Generated Waveform
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: display_samples
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    ylabel: Input Magnitude
    ymax: '.5'
    ymin: '0'
  states: {}
- name: timings_to_bin_0
  id: timings_to_bitfield
  parameters:
    forward_partial: 'False'
    hello_max: '13e-4'
    hello_min: '10e-4'
    high_max: '14e-4'
    low_max: '9e-4'
    low_min: '4e-4'
    sep_max: '8e-4'
    sep_min: '6e-4'
    textual_output: 'False'
  states: {}
- name: timings_to_ookfloat_0
  id: timings_to_ookfloat
  parameters:
    false_value: '0.0'
    idle_value: '0'
    sample_rate: samp_rate
    sep_time: '5e-3'
    sep_value: '0.0'
    true_value: '1.0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: messages
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: messages
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [bitfield_to_timings_0, debug, blocks_message_debug_1, print]
- [bitfield_to_timings_0, out, timings_to_ookfloat_0, in]
- [blocks_burst_tagger_0, '0', blocks_burst_tagger_1, '0']
- [blocks_burst_tagger_1, '0', ook_timings_0, '0']
- [blocks_burst_tagger_1, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', blocks_burst_tagger_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_short_0, '0']
- [blocks_threshold_ff_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_short_1, '0']
- [decode_binfmt_0, debug, blocks_message_debug_0, print]
- [decode_binfmt_0, out, blocks_message_debug_0, print]
- [decode_binfmt_0, out, virtual_sink_0, '0']
- [encode_binfmt_0, debug, blocks_message_debug_1, print]
- [encode_binfmt_0, out, bitfield_to_timings_0, in]
- [message_sanitizer_0, debug, blocks_message_debug_1, print]
- [message_sanitizer_0, out, encode_binfmt_0, in]
- [ook_timings_0, debug, blocks_message_debug_0, print]
- [ook_timings_0, out, timings_to_bin_0, in]
- [timings_to_bin_0, debug, blocks_message_debug_0, print]
- [timings_to_bin_0, out, decode_binfmt_0, in]
- [timings_to_ookfloat_0, '0', blocks_float_to_complex_0, '0']
- [timings_to_ookfloat_0, debug, blocks_message_debug_1, print]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', message_sanitizer_0, in]

metadata:
  file_format: 1
